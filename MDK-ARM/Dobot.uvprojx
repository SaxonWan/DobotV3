# Keil uVision project Dobot.uvprojx, settings and files
target Dobot (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Dobot +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx,USE_HAL_DRIVER,STM32L476xx
  c include: ../Inc;     ../Drivers/STM32L4xx_HAL_Driver/Inc;     ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;     ../Drivers/CMSIS/Device/ST/STM32L4xx/Include;     ../Drivers/CMSIS/Include;     ..\Src\complatform;     ..\Inc\mbedtls;     ..\Inc;     ..\Src\JSON
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Application/User
    ../Src/: command.cpp main.cpp emw3080.c Motor.c gpio.c tim.c usart.c stm32l4xx_it.c stm32l4xx_hal_msp.c dobot.cpp
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group complatform
    ../Src/complatform/: Message.cpp Packet.cpp Protocol.cpp RingBuffer.cpp
  group hmac_sha1
    ../Src/mbedtls/: platform_util.c md_wrap.c md.c sha1.c
    ../Src/: hmac_sha1.c
software components: CMSIS:CORE 4.3.0
